# Keil uVision project platform-controller.uvprojx, settings and files
target platform-controller Configuration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F078VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: platform-controller +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F078xx
  c misc: --C99
  c include: ../Inc;                           ../Drivers/STM32F0xx_HAL_Driver/Inc;                           ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                           ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;             ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;              ../Drivers/CMSIS/Include;                           ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f078xx.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr.c stm32f0xx_hal_dma.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c
  group Application/User
    ../Src/: usb_device.c stm32f0xx_hal_msp.c usbd_desc.c usbd_conf.c main.c sd_platform.c sd_i2c.c sd_spi.c sd_spi_bridge.c sd_usbd_cdc_if.c sd_interrupt.c sd_buffer.c sd_led.c sd_led_pattern.c sd_uart.c sd_button.c sd_pwm.c sd_gpio.c sd_tim.c sd_adc.c sd_dac.c
    ./: power_manager.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 5.0.1
